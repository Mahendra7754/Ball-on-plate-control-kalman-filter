# Keil uVision project BalanceBoard.uvproj, settings and files
target MCBSTM32 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: BallPlateF103
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD, USE_MCBSTM32, __CC, _ARM
  c include: .\init; .\cfg; ..\StdPeriph_Lib; ..\StdPeriph_Lib\STM32F10x_StdPeriph_Driver\inc;.\; ..\StdPeriph_Lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\ucos-ii\core; ..\ucos-ii\stm32f103rb; ..\ucos-ii\cpu
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\obj\BalanceBoard.sct
  group Documentation
    ./: 1ReadMe.txt
    ./app/: shrhelp.h
  group StartupCode
    ./init/: STM32F10x.s
  group InitCode
    ./init/: STM32_Init.c
  group ApplicationCode
    ./cfg/: platform_cfg.h bsp.c bsp.h os_cfg.h
    ./app/: bbSSParams.h bbTypeDefs.h BallPlateMain.c BallPlate.h Controller.c auxSIOcomm.c auxSIOcomm.h Utility.c BallPlateKFlib.h
    ./: BallPlateKFlib.c
  group StdPeripherals
    ../StdPeriph_Lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c
    ../StdPeriph_Lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../StdPeriph_Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../StdPeriph_Lib/: stm32f10x.h
  group basicIO
    ../BasicIO/: mctDefs.h BasicIO.c BasicIO.h
